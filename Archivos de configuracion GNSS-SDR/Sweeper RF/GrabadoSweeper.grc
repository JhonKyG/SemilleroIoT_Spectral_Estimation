options:
  parameters:
    generate_options: qt_gui
    id: PruebaSweeper_1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: audio_dec
  id: variable
  parameters:
    value: '10'
  states: {}
- name: cutoff
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: frecuency
  id: variable_qtgui_label
  parameters:
    label: Frecuencia
    type: int
    value: freq
  states: {}
- name: freq
  id: variable
  parameters:
    value: epy_module_0.frecuencia(funct)
  states: {}
- name: funct
  id: variable_function_probe
  parameters:
    block_id: prueba1
    function_name: level
    poll_rate: time_of_jump
    value: '0'
  states: {}
- name: high_freq
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: low_freq
  id: variable
  parameters:
    value: '900'
  states: {}
- name: quadrature
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '93000'
  states: {}
- name: squelch
  id: variable_qtgui_range
  parameters:
    label: Squelch Level
    orient: Qt.Horizontal
    start: '-100'
    step: '1'
    stop: '0'
    value: '-50'
  states: {}
- name: tiempo
  id: variable
  parameters:
    value: epy_module_0.tiempo(funct, time_of_recording)
  states: {}
- name: tiempo_de_Grabacion
  id: variable_qtgui_label
  parameters:
    label: Tiempo de Grabacion
    type: int
    value: tiempo
  states: {}
- name: time_of_jump
  id: variable
  parameters:
    value: '1'
  states: {}
- name: time_of_recording
  id: variable
  parameters:
    value: '100'
  states: {}
- name: transition
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Volume
    orient: Qt.Horizontal
    start: '0'
    step: '0.25'
    stop: '10'
    value: '1'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '-50'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: audio_dec
    quad_rate: quadrature
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: pulse
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: high_freq
    low_cutoff_freq: low_freq
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '400'
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: epy_module_0
  id: epy_module
  parameters:
    source_code: |
      # this module will be imported in the into your flowgraph
      t = 1; step_freq = 100000; f1 = 88000000; time_max = 0; step_time= 1;
      #88.6e6+(freq*1e6)
      def frecuencia(prob_lvl):
          global t, step, time_max, f1
          if t != time_max:
           f1 += step_freq
           print(prob_lvl)
          return f1
          
              
      def tiempo(prob_lvl, time):
          global t, step, time_max
          time_max = time
          if t != time_max:
           if prob_lvl:
            t += step_time
          return (time_max-t)
  states: {}
- name: osmosdr_source_0_0
  id: osmosdr_source
  parameters:
    args: '"hackrf=0,bias=1"'
    bb_gain0: '20'
    freq0: freq
    gain0: '10'
    gain_mode0: 'True'
    if_gain0: '20'
    iq_balance_mode0: '16'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: prueba1
  id: blocks_probe_signal_x
  parameters:
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    legend: 'False'
    name: '"Frecuencia Pass Band Filter"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    legend: 'False'
    name: '"Frequency Sink HackRF"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    legend: 'False'
    name: '"Time Sink Band Pass Filter"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    legend: 'False'
    name: '"WatterFall HackRF"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"WatterFall Band Pass Filter"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '50'
    interp: '48'
    taps: ''
    type: fff
  states: {}

connections:
- [analog_simple_squelch_cc_0, '0', analog_wfm_rcv_0, '0']
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0_0, '0']
- [band_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [band_pass_filter_0, '0', qtgui_time_sink_x_0, '0']
- [band_pass_filter_0, '0', qtgui_waterfall_sink_x_1, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [osmosdr_source_0_0, '0', band_pass_filter_0, '0']
- [osmosdr_source_0_0, '0', prueba1, '0']
- [osmosdr_source_0_0, '0', qtgui_freq_sink_x_1, '0']
- [osmosdr_source_0_0, '0', qtgui_waterfall_sink_x_0, '0']
- [osmosdr_source_0_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_simple_squelch_cc_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
