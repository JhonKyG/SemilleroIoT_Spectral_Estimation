options:
  parameters:
    generate_options: qt_gui
    id: SweeperGNURadio
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: epy_module_0.sweeper(func)
  states: {}
- name: freqq
  id: variable_qtgui_label
  parameters:
    label: Frecuencia
    type: real
    value: freq
  states: {}
- name: func
  id: variable_function_probe
  parameters:
    block_id: bloqueSignal
    function_name: level
    poll_rate: vel
    value: '0'
  states: {}
- name: funcTime
  id: variable_function_probe
  parameters:
    block_id: bloqueTime
    function_name: level
    poll_rate: '1'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: tiempo
  id: variable
  parameters:
    value: epy_module_0.funTime(funcTime)
  states: {}
- name: timee
  id: variable_qtgui_label
  parameters:
    label: Tiempo
    type: int
    value: tiempo
  states: {}
- name: vel
  id: variable
  parameters:
    value: epy_module_0.vel(func)
  states: {}
- name: bloqueSignal
  id: blocks_probe_signal_x
  parameters:
    type: complex
  states: {}
- name: bloqueTime
  id: blocks_probe_signal_x
  parameters:
    type: complex
  states: {}
- name: epy_module_0
  id: epy_module
  parameters:
    source_code: |
      # this module will be imported in the into your flowgraph
      var = {'f1':88e6, 'f2':108e6, 'step':1e5}#var = {'f1': 88e6, 'f2':108e6, 'step':1e5}

      f1 = var['f1']; f2 = var['f2']; step = var['step']; 
      velocidad = 1; timeI = 1;

      def sweeper(prob_lvl):
       global f1, f2, step
       if f1 < f2:
        f1+=step
        return f1
       else:
        return f2
       
      def funTime(funcTime):
       global timeI
       timeI += 1 
       return timeI

      def vel(prob_lvl):
       global velocidad, timeI
       print(prob_lvl)
       if timeI > 5:
        return 1
       else:
        return 1
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"hackrf=0,bias=1"'
    bb_gain0: '20'
    freq0: freq
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    axislabels: 'False'
    color1: dark green
    legend: 'False'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    legend: 'False'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [osmosdr_source_0, '0', bloqueSignal, '0']
- [osmosdr_source_0, '0', bloqueTime, '0']
- [osmosdr_source_0, '0', qtgui_time_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
